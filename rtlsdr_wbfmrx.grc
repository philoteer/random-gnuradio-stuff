options:
  parameters:
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: amax
  id: variable_function_probe
  parameters:
    block_id: amax_probe
    function_name: level
    poll_rate: '10'
    value: '0'
  states: {}
- name: amax2
  id: variable
  parameters:
    value: amax
  states: {}
- name: avg_before_argmax
  id: variable
  parameters:
    value: '100'
  states: {}
- name: fftlen
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: freq
  id: variable
  parameters:
    value: freq_M*1e6
  states: {}
- name: freq_M
  id: variable_qtgui_range
  parameters:
    label: Frequency (Mhz)
    orient: Qt.Horizontal
    start: '1'
    step: '0.1'
    stop: '6000'
    value: '435'
  states: {}
- name: rf_amp
  id: variable_qtgui_range
  parameters:
    label: RF Gain
    orient: Qt.Horizontal
    start: '-8.6'
    step: '0.1'
    stop: '18.7'
    value: '-8.6'
  states: {}
- name: samp_M
  id: variable_qtgui_range
  parameters:
    label: Sampling Rate (MS/s)
    orient: Qt.Horizontal
    start: '1'
    step: '1'
    stop: '3.2'
    value: '2.4'
  states: {state: disabled}
- name: samp_M
  id: variable
  parameters:
    value: '2.4'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: samp_M*1e6
  states: {}
- name: amax_probe
  id: blocks_probe_signal_x
  parameters:
    type: short
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: (((fftlen/2)-amax2)/float(fftlen))*samp_rate
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '1'
    quad_rate: 250e3
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blah
  id: virtual_source
  parameters:
    stream_id: signal_tuned
  states: {}
- name: blocks_argmax_xx_0
  id: blocks_argmax_xx
  parameters:
    comment: Frequency-domain Peak-finder (argmax)
    num_inputs: '1'
    type: float
    vlen: '1024'
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: fftlen
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: '16'
    type: float
    vlen: fftlen
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: avg_before_argmax
    max_iter: '4000'
    scale: '1'
    type: float
    vlen: fftlen
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '[1.0/fftlen] * fftlen'
    type: complex
    vlen: fftlen
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '[1] * int(fftlen/2) + [0] + [1] * int(fftlen/2-1)'
    type: float
    vlen: fftlen
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
    vlen: fftlen
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: short
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: fftlen
    type: complex
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Vector Position Indicator
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block

      	def __init__(self, pos_init=2, pos_end=3, veclen=1024):  
      		"""arguments to this function show up as parameters in GRC"""
      		gr.sync_block.__init__(
      			self,
      			name='Vector Position Indicator',   # will show up in GRC
      			in_sig=[],
      			out_sig=[(np.float32, veclen)]
      		)
      		self.pos_init = pos_init
      		self.pos_end = pos_end
      		self.veclen = veclen

      	def work(self, input_items, output_items):
      		try:
      			output_items[0][0][:] = np.zeros(self.veclen, dtype=np.float32) - 1000
      			output_items[0][0][int(self.pos_init):int(self.pos_end)] = np.zeros(int(self.pos_end-self.pos_init), dtype=np.float32) + 1000
      		except:
      			pass
      		for i in range (1, len(output_items[0])):
      			output_items[0][i][:] = output_items[0][0][:]
      		return len(output_items[0])
    comment: GUI Plot
    pos_end: min(amax2+10,fftlen-1)
    pos_init: max(amax2-10,0)
    veclen: fftlen
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: fftlen
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(fftlen)
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 100e3
    decim: '2'
    gain: '1'
    samp_rate: 500e3
    type: fir_filter_ccf
    width: 200e3
    win: firdes.WIN_HAMMING
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: ''
    bb_gain0: '0'
    bw0: samp_rate
    freq0: freq
    gain0: rf_amp
    gain_mode0: 'False'
    if_gain0: '0'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    name: '"Power Spectrum"'
    nconnections: '2'
    showports: 'True'
    vlen: fftlen
    x_axis_label: '"Freq (MHz)"'
    x_start: freq_M - (samp_M/2)
    x_step: float(samp_M)/fftlen
    x_units: '"(MHz)"'
    y_axis_label: '"Power (dBFS)"'
    y_units: '"dBFS"'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    comment: to 500kS/s
    decim: int(samp_M *2 * 10)
    interp: 1 * 10
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '125'
    interp: '24'
    taps: ''
    type: fff
  states: {}
- name: sigt
  id: virtual_sink
  parameters:
    comment: periodogram (dB scale)
    stream_id: signal_tuned
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    comment: periodogram (dB scale)
    stream_id: psd_dB
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    comment: periodogram (linear)
    stream_id: psd_linear
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    comment: Incoming I-Q signal
    stream_id: sig_in
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: psd_dB
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: sig_in
  states: {}
- name: virtual_source_1_0
  id: virtual_source
  parameters:
    stream_id: psd_linear
  states: {}
- name: virtual_source_1_1
  id: virtual_source
  parameters:
    stream_id: psd_linear
  states: {}
- name: virtual_source_1_2
  id: virtual_source
  parameters:
    stream_id: sig_in
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [analog_wfm_rcv_0, '0', rational_resampler_xxx_1, '0']
- [blah, '0', rational_resampler_xxx_0, '0']
- [blocks_argmax_xx_0, '0', amax_probe, '0']
- [blocks_argmax_xx_0, '1', blocks_null_sink_0, '0']
- [blocks_complex_to_mag_squared_0, '0', virtual_sink_0_0, '0']
- [blocks_keep_one_in_n_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_moving_average_xx_0, '0', blocks_argmax_xx_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_moving_average_xx_0, '0']
- [blocks_multiply_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_multiply_xx_0, '0', sigt, '0']
- [blocks_nlog10_ff_0, '0', virtual_sink_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [epy_block_0, '0', qtgui_vector_sink_f_0, '1']
- [fft_vxx_0, '0', blocks_multiply_const_vxx_0, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv_0, '0']
- [osmosdr_source_0, '0', virtual_sink_1, '0']
- [rational_resampler_xxx_0, '0', low_pass_filter_0, '0']
- [rational_resampler_xxx_1, '0', audio_sink_0, '0']
- [virtual_source_0, '0', qtgui_vector_sink_f_0, '0']
- [virtual_source_1, '0', blocks_stream_to_vector_0, '0']
- [virtual_source_1_0, '0', blocks_multiply_const_vxx_1, '0']
- [virtual_source_1_1, '0', blocks_keep_one_in_n_0, '0']
- [virtual_source_1_2, '0', blocks_multiply_xx_0, '0']

metadata:
  file_format: 1
