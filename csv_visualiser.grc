options:
  parameters:
    generate_options: qt_gui
    id: parse_csv
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '24000'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {state: disabled}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1/32768
    type: float
  states: {state: disabled}
- name: blocks_probe_rate_0
  id: blocks_probe_rate
  parameters:
    alpha: '0.15'
    mintime: '500.0'
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
      	"""Embedded Python Block example - a simple multiply const"""

      	def __init__(self, file_path="바탕화면/정상_rawdata_5분_인터벌(속도)별_테스트용/normal_raw_data_for_test_5min_inverter1/head_pulley_acceleration_accel_x.csv"):  # only default arguments here
      		"""arguments to this function show up as parameters in GRC"""
      		gr.sync_block.__init__(
      			self,
      			name='CSV Parser',   # will show up in GRC
      			in_sig=[],
      			out_sig=[np.float32]
      		)
      		self.file_path = file_path
      		try:
      			self.csv = np.loadtxt(file_path, delimiter=",", dtype=np.float32)
      		except:
      			self.csv = []
      		self.pos = 0
      		self.csv_len = len(self.csv)

      	def work(self, input_items, output_items):
      		next_pos = min(self.pos + len(output_items[0]), self.csv_len)
      		out_len = next_pos - self.pos
      		
      		output_items[0][0:out_len] = self.csv[self.pos:self.pos+out_len]
      		
      		if(next_pos == self.csv_len):
      			self.pos = 0
      		else:
      			self.pos = next_pos
      			
      		return out_len
    file_path: '"/home/piloteer/foo.csv"'
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_probe_rate_0, rate, blocks_message_debug_0, print]
- [blocks_throttle_0, '0', qtgui_sink_x_0, '0']
- [epy_block_0, '0', blocks_multiply_const_vxx_0, '0']
- [epy_block_0, '0', blocks_probe_rate_0, '0']
- [epy_block_0, '0', blocks_throttle_0, '0']

metadata:
  file_format: 1
