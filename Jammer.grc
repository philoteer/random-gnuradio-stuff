<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>cw_jamming_fc</value></param>
<param><key>value</key><value>1e3</value></param>
<param><key>gui_hint</key><value>tab_0@1 : 4,0</value></param>
<param><key>label</key><value>cw_jamming_fc</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>if_gain</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>tab_0@1 : 2,0</value></param>
<param><key>label</key><value>IF_Gain</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>47</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>image_filepath</value></param>
<param><key>value</key><value>"/home/piloteer/Untitled Diagram.png"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>image_original_pixel_width</value></param>
<param><key>value</key><value>68</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>jamming_mode</value></param>
<param><key>value</key><value>1</value></param>
<param><key>label0</key><value>'Off'</value></param>
<param><key>label1</key><value>"CW"</value></param>
<param><key>label2</key><value>"Pluse CW"</value></param>
<param><key>label3</key><value>"Noise"</value></param>
<param><key>label4</key><value>"OFDM Paint"</value></param>
<param><key>num_opts</key><value>5</value></param>
<param><key>option0</key><value>1</value></param>
<param><key>option1</key><value>2</value></param>
<param><key>option2</key><value>3</value></param>
<param><key>option3</key><value>4</value></param>
<param><key>option4</key><value>5</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>noise_decimation</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>noise_interpolation</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>pulsecw_vector</value></param>
<param><key>value</key><value>[1] * 10 + [0] * 10</value></param>
<param><key>gui_hint</key><value>tab_0@1 : 5,0</value></param>
<param><key>label</key><value>pulsecw_vector</value></param>
<param><key>type</key><value>raw</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>radio_fc</value></param>
<param><key>value</key><value>radio_fc_MHz *1e6</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>radio_fc_MHz</value></param>
<param><key>value</key><value>1000</value></param>
<param><key>gui_hint</key><value>tab_0@1 : 0,0</value></param>
<param><key>label</key><value>Transmitter Center Frequency (MHz)</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>50</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>6000</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>rf_gain</value></param>
<param><key>value</key><value>14</value></param>
<param><key>gui_hint</key><value>tab_0@1 : 1,0</value></param>
<param><key>label</key><value>RF_Gain</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>14</value></param>
<param><key>stop</key><value>14</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>samp_rate_MHz*1e6</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>samp_rate_MHz</value></param>
<param><key>value</key><value>2.5</value></param>
<param><key>gui_hint</key><value>tab_0@1 : 3,0</value></param>
<param><key>label</key><value>Sampling Rate (MHz)</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>analog_const_source_x_0</value></param>
<param><key>comment</key><value>(actually unnecessary)</value></param>
<param><key>const</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>analog_fastnoise_source_x</key>
<param><key>id</key><value>analog_fastnoise_source_x_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>noise_type</key><value>analog.GR_GAUSSIAN</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>seed</key><value>0</value></param>
<param><key>samples</key><value>8192</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>freq</key><value>cw_jamming_fc</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_inputs</key><value>5</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>(jamming_mode == 2)</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0</value></param>
<param><key>const</key><value>(jamming_mode == 1)</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_1</value></param>
<param><key>const</key><value>(jamming_mode == 3)</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_1_0</value></param>
<param><key>const</key><value>(jamming_mode == 4)</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_1_0_0</value></param>
<param><key>const</key><value>(jamming_mode == 5)</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>4096</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>blocks_vector_source_x_0</value></param>
<param><key>comment</key><value>Pulse CW Jammer
Pulse p(t)</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>vector</key><value>pulsecw_vector</value></param>
</block>
<block>
<key>digital_ofdm_cyclic_prefixer</key>
<param><key>id</key><value>digital_ofdm_cyclic_prefixer_0</value></param>
<param><key>cp_len</key><value>4096/8</value></param>
<param><key>input_size</key><value>4096</value></param>
<param><key>tagname</key><value></value></param>
</block>
<block>
<key>osmosdr_sink</key>
<param><key>id</key><value>osmosdr_sink_0</value></param>
<param><key>bb_gain0</key><value>0</value></param>
<param><key>bw0</key><value>samp_rate</value></param>
<param><key>freq0</key><value>radio_fc</value></param>
<param><key>if_gain0</key><value>(if_gain) * (jamming_mode != 1)</value></param>
<param><key>gain0</key><value>(rf_gain) * (jamming_mode != 1)</value></param>
<param><key>args</key><value></value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>paint_image_source</key>
<param><key>id</key><value>paint_image_source_0</value></param>
<param><key>autocontrast</key><value>1</value></param>
<param><key>image_flip</key><value>0</value></param>
<param><key>bt709_map</key><value>1</value></param>
<param><key>image_file</key><value>image_filepath</value></param>
<param><key>image_invert</key><value>1</value></param>
<param><key>repeatmode</key><value>1</value></param>
</block>
<block>
<key>paint_paint_bc</key>
<param><key>id</key><value>paint_paint_bc_0</value></param>
<param><key>width</key><value>image_original_pixel_width</value></param>
<param><key>repeats</key><value>1</value></param>
<param><key>randomsrc</key><value>INTERNAL</value></param>
<param><key>equalization</key><value>EQUALIZATION_OFF</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>radio_fc</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>tab_0@0</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0</value></param>
<param><key>decim</key><value>noise_decimation</value></param>
<param><key>interp</key><value>noise_interpolation</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>tab_0</value></param>
<param><key>label0</key><value>Spectrogram</value></param>
<param><key>label1</key><value>Control</value></param>
<param><key>num_tabs</key><value>2</value></param>
</block>
<connection><source_block_id>analog_const_source_x_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_fastnoise_source_x_0</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>osmosdr_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_1</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_1_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_1_0_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>4</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0</source_block_id><sink_block_id>digital_ofdm_cyclic_prefixer_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>digital_ofdm_cyclic_prefixer_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_1_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>paint_image_source_0</source_block_id><sink_block_id>paint_paint_bc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>paint_paint_bc_0</source_block_id><sink_block_id>blocks_stream_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
