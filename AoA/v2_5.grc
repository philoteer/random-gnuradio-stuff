<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>a_ant</value></param>
<param><key>value</key><value>a_ant_selector</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>a_ant_selector</value></param>
<param><key>value</key><value>"TX/RX"</value></param>
<param><key>label0</key><value>"RX2"</value></param>
<param><key>label1</key><value>"TX/RX"</value></param>
<param><key>num_opts</key><value>2</value></param>
<param><key>option0</key><value>"RX2"</value></param>
<param><key>option1</key><value>"TX/RX"</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>a_ant_x</value></param>
<param><key>value</key><value>a_rx2_x if a_ant == "RX2" else a_rx1_x</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>a_ant_y</value></param>
<param><key>value</key><value>a_rx2_y if a_ant == "RX2" else a_rx1_y</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>a_rx1_a_rx_2_dist</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>math.sqrt((a_rx1_x - a_rx2_x)**2 + (a_rx1_y - a_rx2_y)**2)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>a_rx1_b_rx_1_dist</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>math.sqrt((a_rx1_x - b_rx1_x)**2 + (a_rx1_y - b_rx1_y)**2)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>a_rx1_b_rx_2_dist</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>math.sqrt((a_rx1_x - b_rx2_x)**2 + (a_rx1_y - b_rx2_y)**2)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>a_rx1_to_a_rx_2_ang</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>math.atan2((a_rx2_y - a_rx1_y),(a_rx2_x - a_rx1_x))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>a_rx1_to_b_rx_1_ang</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>math.atan2((b_rx1_y - a_rx1_y),(b_rx1_x - a_rx1_x))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>a_rx1_to_b_rx_2_ang</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>math.atan2((b_rx2_y - a_rx1_y),(b_rx2_x - a_rx1_x))</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>a_rx1_x</value></param>
<param><key>value</key><value>24</value></param>
<param><key>gui_hint</key><value>tab@2</value></param>
<param><key>label</key><value>CH1 TX/RX X Coord (cm)</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>a_rx1_y</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>tab@2</value></param>
<param><key>label</key><value>CH1 TX/RX Y Coord (cm)</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>a_rx2_b_rx_1_dist</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>math.sqrt((a_rx2_x - b_rx1_x)**2 + (a_rx2_y - b_rx1_y)**2)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>a_rx2_b_rx_2_dist</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>math.sqrt((a_rx2_x - b_rx2_x)**2 + (a_rx2_y - b_rx2_y)**2)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>a_rx2_to_b_rx_1_ang</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>math.atan2((b_rx1_y - a_rx2_y),(b_rx1_x - a_rx2_x))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>a_rx2_to_b_rx_2_ang</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>math.atan2((b_rx2_y - a_rx2_y),(b_rx2_x - a_rx2_x))</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>a_rx2_x</value></param>
<param><key>value</key><value>16</value></param>
<param><key>gui_hint</key><value>tab@2</value></param>
<param><key>label</key><value>CH1 RX2 X Coord (cm)</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>a_rx2_y</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>tab@2</value></param>
<param><key>label</key><value>CH1 RX2 Y Coord (cm)</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>b_ant</value></param>
<param><key>value</key><value>b_ant_selector</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>b_ant_selector</value></param>
<param><key>value</key><value>"RX2"</value></param>
<param><key>label0</key><value>"RX2"</value></param>
<param><key>label1</key><value>"TX/RX"</value></param>
<param><key>num_opts</key><value>2</value></param>
<param><key>option0</key><value>"RX2"</value></param>
<param><key>option1</key><value>"TX/RX"</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>b_ant_x</value></param>
<param><key>value</key><value>b_rx2_x if b_ant == "RX2" else b_rx1_x</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>b_ant_y</value></param>
<param><key>value</key><value>b_rx2_y if a_ant == "RX2" else b_rx1_y</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>b_rx1_b_rx_2_dist</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>math.sqrt((b_rx1_x - b_rx2_x)**2 + (b_rx1_y - b_rx2_y)**2)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>b_rx1_to_b_rx_2_ang</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>math.atan2((b_rx2_y - b_rx1_y),(b_rx2_x - b_rx1_x))</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>b_rx1_x</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>tab@2</value></param>
<param><key>label</key><value>CH2 TX/RX X Coord (cm)</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>b_rx1_y</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>tab@2</value></param>
<param><key>label</key><value>CH2 TX/RX Y Coord (cm)</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>b_rx2_x</value></param>
<param><key>value</key><value>8</value></param>
<param><key>gui_hint</key><value>tab@2</value></param>
<param><key>label</key><value>CH2 RX2 X Coord (cm)</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>b_rx2_y</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>tab@2</value></param>
<param><key>label</key><value>CH2 RX2 Y Coord (cm)</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>cal</value></param>
<param><key>value</key><value>0</value></param>
<param><key>label</key><value>"Calibration Angle (Rad)"</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>math.pi/180</value></param>
<param><key>stop</key><value>2*math.pi</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>current_ant_ang</value></param>
<param><key>value</key><value>math.atan2((b_ant_y - a_ant_y),(b_ant_x - a_ant_x))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>current_ant_ang_degree</value></param>
<param><key>value</key><value>current_ant_ang * 180/math.pi</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>current_ant_dist</value></param>
<param><key>value</key><value>math.sqrt((a_ant_x - b_ant_x)**2 + (a_ant_y - b_ant_y)**2)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq</value></param>
<param><key>value</key><value>freq_M * 1e6</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>freq_M</value></param>
<param><key>value</key><value>910</value></param>
<param><key>label</key><value>Center Frequency (MHz)</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>50</value></param>
<param><key>step</key><value>0.1</value></param>
<param><key>stop</key><value>6000</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>gain</value></param>
<param><key>value</key><value>20</value></param>
<param><key>label</key><value>Rx Gain (dB)</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>2</value></param>
<param><key>stop</key><value>76</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>s3_avg</value></param>
<param><key>value</key><value>64</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>s3_decim</value></param>
<param><key>value</key><value>16</value></param>
<param><key>gui_hint</key><value>tab@1</value></param>
<param><key>label</key><value>Decimation </value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>s3_freq_shift</value></param>
<param><key>value</key><value>- s3_target_qt* 1e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>s3_keep</value></param>
<param><key>value</key><value>16</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>s3_target_qt</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>tab@1</value></param>
<param><key>label</key><value>Target Frequency (MHz)</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-samp_rate_M/2</value></param>
<param><key>step</key><value>0.03</value></param>
<param><key>stop</key><value>samp_rate_M/2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>s3_throw</value></param>
<param><key>value</key><value>1024</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>samp_rate_M * 1e6</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>samp_rate_M</value></param>
<param><key>value</key><value>4</value></param>
<param><key>gui_hint</key><value>tab@2</value></param>
<param><key>label</key><value>Sampling Rate (MHz)</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0.1</value></param>
<param><key>step</key><value>0.1</value></param>
<param><key>stop</key><value>56</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>shift_in_degree</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>tab@0</value></param>
<param><key>label</key><value>"Angle"</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.5</value></param>
<param><key>stop</key><value>360</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>shift_in_radians</value></param>
<param><key>value</key><value>(shift_in_degree / 180) * math.pi</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>wavelength</value></param>
<param><key>value</key><value>3e8/freq</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>freq</key><value>s3_freq_shift</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_keep_m_in_n</key>
<param><key>id</key><value>blocks_keep_m_in_n_0</value></param>
<param><key>m</key><value>s3_keep</value></param>
<param><key>n</key><value>s3_throw + s3_keep</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>offset</key><value>0</value></param>
</block>
<block>
<key>blocks_keep_m_in_n</key>
<param><key>id</key><value>blocks_keep_m_in_n_0_0</value></param>
<param><key>m</key><value>s3_keep</value></param>
<param><key>n</key><value>s3_throw + s3_keep</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>offset</key><value>0</value></param>
</block>
<block>
<key>blocks_keep_m_in_n</key>
<param><key>id</key><value>blocks_keep_m_in_n_0_1</value></param>
<param><key>m</key><value>s3_keep</value></param>
<param><key>n</key><value>s3_throw + s3_keep</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>offset</key><value>0</value></param>
</block>
<block>
<key>blocks_moving_average_xx</key>
<param><key>id</key><value>blocks_moving_average_xx_0</value></param>
<param><key>length</key><value>s3_avg</value></param>
<param><key>max_iter</key><value>s3_avg *4</value></param>
<param><key>scale</key><value>1.0/s3_avg</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_1</value></param>
<param><key>const</key><value>180/math.pi</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_2</value></param>
<param><key>const</key><value>wavelength/(current_ant_dist/100)</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_xx</key>
<param><key>id</key><value>blocks_multiply_const_xx_0</value></param>
<param><key>const</key><value>math.cos(cal) + math.sin(cal)*1j</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_const_xx</key>
<param><key>id</key><value>blocks_multiply_const_xx_1</value></param>
<param><key>const</key><value>math.cos(shift_in_radians) + math.sin(shift_in_radians)*1j</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>s3_keep</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>s3_keep</value></param>
</block>
<block>
<key>doa_capon_ccf</key>
<param><key>id</key><value>doa_capon_ccf_0</value></param>
<param><key>vlen</key><value>16</value></param>
</block>
<block>
<key>doa_phase2doa_ff</key>
<param><key>id</key><value>doa_phase2doa_ff_0</value></param>
<param><key>alpha</key><value>1</value></param>
</block>
<block>
<key>doa_qt_compass</key>
<param><key>id</key><value>doa_qt_compass_0</value></param>
<param><key>arc_bias</key><value>0</value></param>
<param><key>comment</key><value>plot</value></param>
<param><key>gui_hint</key><value>tab@1</value></param>
<param><key>max_val</key><value>90</value></param>
<param><key>min_val</key><value>-90</value></param>
<param><key>name</key><value>""</value></param>
<param><key>step</key><value>10</value></param>
<param><key>update_time</key><value>0.10</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import math,cmath</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0</value></param>
<param><key>note</key><value>Antenna dist / angle</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_0</value></param>
<param><key>note</key><value>USRP src setting</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_1</value></param>
<param><key>note</key><value>Cannot change Alpha of P to DOA on real time</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_2</value></param>
<param><key>comment</key><value>Antenna Locations, Angles.</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_2_0</value></param>
<param><key>comment</key><value>Freq, Gain, Antenna choice, etc.</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_3</value></param>
<param><key>comment</key><value>USRP Source -&gt; Power equalizer</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_4</value></param>
<param><key>comment</key><value>Phase shift -&gt; plot PSD estmiates.</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_4_0</value></param>
<param><key>comment</key><value>The main DoA Routine.</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_5</value></param>
<param><key>comment</key><value>Digital Freq Shift (so as the signal of interest will locate at 0Hz)</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_6</value></param>
<param><key>comment</key><value>Decimator -&gt; DoA Estimator</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_7</value></param>
<param><key>comment</key><value>Moving Avg</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_8</value></param>
<param><key>comment</key><value>Convert to a standard Angle</value></param>
</block>
<block>
<key>pfb_decimator_ccf</key>
<param><key>id</key><value>pfb_decimator_ccf_0</value></param>
<param><key>decim</key><value>s3_decim</value></param>
<param><key>channel</key><value>0</value></param>
<param><key>atten</key><value>100</value></param>
</block>
<block>
<key>pfb_decimator_ccf</key>
<param><key>id</key><value>pfb_decimator_ccf_0_0</value></param>
<param><key>decim</key><value>s3_decim</value></param>
<param><key>channel</key><value>0</value></param>
<param><key>atten</key><value>100</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>average</key><value>0.1</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>freq</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>tab@0</value></param>
<param><key>name</key><value>"PSD Plot"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>tab</value></param>
<param><key>label0</key><value>PSD</value></param>
<param><key>label1</key><value>Compass</value></param>
<param><key>label2</key><value>Config</value></param>
<param><key>num_tabs</key><value>3</value></param>
</block>
<block>
<key>twochannel_power_equalizer</key>
<param><key>id</key><value>twochannel_power_equalizer_0</value></param>
<param><key>keep</key><value>1024</value></param>
<param><key>throw</key><value>100000</value></param>
<param><key>avg_len</key><value>1024</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value>a_ant</value></param>
<param><key>bw0</key><value>samp_rate</value></param>
<param><key>center_freq0</key><value>freq</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>gain</value></param>
<param><key>ant1</key><value>b_ant</value></param>
<param><key>bw1</key><value>samp_rate</value></param>
<param><key>center_freq1</key><value>freq</value></param>
<param><key>dc_offs_enb1</key><value>""</value></param>
<param><key>iq_imbal_enb1</key><value>""</value></param>
<param><key>norm_gain1</key><value>False</value></param>
<param><key>gain1</key><value>gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>sd_spec0</key><value>"A:A A:B"</value></param>
<param><key>nchan</key><value>2</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value>sync</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0</value></param>
<param><key>stream_id</key><value>a_out</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_0</value></param>
<param><key>stream_id</key><value>b_out</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0</value></param>
<param><key>stream_id</key><value>b_out</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_0</value></param>
<param><key>stream_id</key><value>a_out</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_0_0</value></param>
<param><key>stream_id</key><value>a_out</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_1</value></param>
<param><key>stream_id</key><value>b_out</value></param>
</block>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blocks_keep_m_in_n_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_m_in_n_0</source_block_id><sink_block_id>blocks_multiply_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_keep_m_in_n_0_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_keep_m_in_n_0_1</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_m_in_n_0_1</source_block_id><sink_block_id>blocks_multiply_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_moving_average_xx_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1</source_block_id><sink_block_id>doa_qt_compass_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_2</source_block_id><sink_block_id>doa_phase2doa_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_xx_0</source_block_id><sink_block_id>virtual_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_xx_1</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>pfb_decimator_ccf_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0_0</source_block_id><sink_block_id>pfb_decimator_ccf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0</source_block_id><sink_block_id>doa_capon_ccf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0_0</source_block_id><sink_block_id>doa_capon_ccf_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>doa_capon_ccf_0</source_block_id><sink_block_id>blocks_moving_average_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>doa_phase2doa_ff_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_decimator_ccf_0</source_block_id><sink_block_id>blocks_stream_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_decimator_ccf_0_0</source_block_id><sink_block_id>blocks_stream_to_vector_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>twochannel_power_equalizer_0</source_block_id><sink_block_id>virtual_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>twochannel_power_equalizer_0</source_block_id><sink_block_id>blocks_multiply_const_xx_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>twochannel_power_equalizer_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>twochannel_power_equalizer_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>virtual_source_0</source_block_id><sink_block_id>blocks_multiply_const_xx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_0_0</source_block_id><sink_block_id>blocks_keep_m_in_n_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_1</source_block_id><sink_block_id>blocks_keep_m_in_n_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
