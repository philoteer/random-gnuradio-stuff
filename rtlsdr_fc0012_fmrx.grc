<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>amax</value></param>
<param><key>block_id</key><value>amax_probe</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>value</key><value>0</value></param>
<param><key>poll_rate</key><value>10</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>amax2</value></param>
<param><key>value</key><value>amax</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>avg_before_argmax</value></param>
<param><key>value</key><value>100</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fftlen</value></param>
<param><key>value</key><value>1024</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq</value></param>
<param><key>value</key><value>freq_M*1e6</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>freq_M</value></param>
<param><key>value</key><value>449</value></param>
<param><key>label</key><value>Frequency (Mhz)</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>1</value></param>
<param><key>step</key><value>0.1</value></param>
<param><key>stop</key><value>6000</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>rf_amp</value></param>
<param><key>value</key><value>18.7</value></param>
<param><key>label</key><value>RF Gain</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-8.6</value></param>
<param><key>step</key><value>0.1</value></param>
<param><key>stop</key><value>18.7</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_M</value></param>
<param><key>value</key><value>2.4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>samp_M*1e6</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>squelch_control</value></param>
<param><key>value</key><value>-35</value></param>
<param><key>label</key><value>Squelch Threshold</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-100</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>0</value></param>
</block>
<block>
<key>blocks_probe_signal_x</key>
<param><key>id</key><value>amax_probe</value></param>
<param><key>type</key><value>short</value></param>
</block>
<block>
<key>analog_nbfm_rx</key>
<param><key>id</key><value>analog_nbfm_rx_0</value></param>
<param><key>audio_rate</key><value>48000</value></param>
<param><key>max_dev</key><value>5e3</value></param>
<param><key>quad_rate</key><value>int(samp_rate/10)</value></param>
<param><key>tau</key><value>75e-6</value></param>
</block>
<block>
<key>analog_pwr_squelch_xx</key>
<param><key>id</key><value>analog_pwr_squelch_xx_0</value></param>
<param><key>alpha</key><value>1e-4</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gate</key><value>True</value></param>
<param><key>ramp</key><value>0</value></param>
<param><key>threshold</key><value>squelch_control</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>analog_pwr_squelch_xx</key>
<param><key>id</key><value>analog_pwr_squelch_xx_0_0</value></param>
<param><key>alpha</key><value>1e-4</value></param>
<param><key>gate</key><value>True</value></param>
<param><key>ramp</key><value>0</value></param>
<param><key>threshold</key><value>squelch_control</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>freq</key><value>(((fftlen/2)-amax2)/float(fftlen))*samp_rate</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>analog_wfm_rcv</key>
<param><key>id</key><value>analog_wfm_rcv_0</value></param>
<param><key>audio_decimation</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>quad_rate</key><value>250e3</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samp_rate</key><value>48000</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samp_rate</key><value>48000</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>blah</value></param>
<param><key>comment</key><value>WBFM Path</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>stream_id</key><value>signal_tuned</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>blah_0</value></param>
<param><key>comment</key><value>N
BFM Path</value></param>
<param><key>stream_id</key><value>signal_tuned</value></param>
</block>
<block>
<key>blocks_argmax_xx</key>
<param><key>id</key><value>blocks_argmax_xx_0</value></param>
<param><key>comment</key><value>Frequency-domain Peak-finder (argmax)</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_inputs</key><value>1</value></param>
<param><key>vlen</key><value>1024</value></param>
</block>
<block>
<key>blocks_complex_to_mag_squared</key>
<param><key>id</key><value>blocks_complex_to_mag_squared_0</value></param>
<param><key>vlen</key><value>fftlen</value></param>
</block>
<block>
<key>blocks_keep_one_in_n</key>
<param><key>id</key><value>blocks_keep_one_in_n_0</value></param>
<param><key>n</key><value>16</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>fftlen</value></param>
</block>
<block>
<key>blocks_moving_average_xx</key>
<param><key>id</key><value>blocks_moving_average_xx_0</value></param>
<param><key>vlen</key><value>fftlen</value></param>
<param><key>length</key><value>avg_before_argmax</value></param>
<param><key>max_iter</key><value>4000</value></param>
<param><key>scale</key><value>1</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>[1.0/fftlen] * fftlen</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>fftlen</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_1</value></param>
<param><key>const</key><value>[1] * (fftlen/2) + [0] + [1] * (fftlen/2-1)</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>fftlen</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_nlog10_ff</key>
<param><key>id</key><value>blocks_nlog10_ff_0</value></param>
<param><key>vlen</key><value>fftlen</value></param>
<param><key>k</key><value>0</value></param>
<param><key>n</key><value>10</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>short</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>fftlen</value></param>
</block>
<block>
<key>blocks_wavfile_sink</key>
<param><key>id</key><value>blocks_wavfile_sink_0</value></param>
<param><key>bits_per_sample</key><value>8</value></param>
<param><key>file</key><value>D:\1.wav</value></param>
<param><key>samp_rate</key><value>48000</value></param>
</block>
<block>
<key>blocks_wavfile_sink</key>
<param><key>id</key><value>blocks_wavfile_sink_0_0</value></param>
<param><key>bits_per_sample</key><value>8</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/piloteer/바탕화면/test.wav</value></param>
<param><key>samp_rate</key><value>48000</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>epy_block_0</value></param>
<param><key>_source_code</key><value>"""
Vector Position Indicator
"""

import numpy as np
from gnuradio import gr


class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block

	def __init__(self, pos_init=2, pos_end=3, veclen=1024):  
		"""arguments to this function show up as parameters in GRC"""
		gr.sync_block.__init__(
			self,
			name='Vector Position Indicator',   # will show up in GRC
			in_sig=[],
			out_sig=[(np.float32, veclen)]
		)
		self.pos_init = pos_init
		self.pos_end = pos_end
		self.veclen = veclen

	def work(self, input_items, output_items):
		try:
			output_items[0][0][:] = np.zeros(self.veclen, dtype=np.float32) - 1000
			output_items[0][0][int(self.pos_init):int(self.pos_end)] = np.zeros(int(self.pos_end-self.pos_init), dtype=np.float32) + 1000
		except:
			pass
		for i in range (1, len(output_items[0])):
			output_items[0][i][:] = output_items[0][0][:]
		return len(output_items[0])
</value></param>
<param><key>comment</key><value>GUI Plot</value></param>
<param><key>pos_end</key><value>min(amax2+10,fftlen-1)</value></param>
<param><key>pos_init</key><value>max(amax2-10,0)</value></param>
<param><key>veclen</key><value>fftlen</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_0</value></param>
<param><key>fft_size</key><value>fftlen</value></param>
<param><key>forward</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>shift</key><value>True</value></param>
<param><key>window</key><value>window.blackmanharris(fftlen)</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0</value></param>
<param><key>cutoff_freq</key><value>100e3</value></param>
<param><key>decim</key><value>2</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>500e3</value></param>
<param><key>width</key><value>200e3</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0_0</value></param>
<param><key>cutoff_freq</key><value>5000</value></param>
<param><key>decim</key><value>10</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>width</key><value>2000</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>osmosdr_source</key>
<param><key>id</key><value>osmosdr_source_0</value></param>
<param><key>bb_gain0</key><value>0</value></param>
<param><key>bw0</key><value>samp_rate</value></param>
<param><key>freq0</key><value>freq</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>0</value></param>
<param><key>gain0</key><value>rf_amp</value></param>
<param><key>args</key><value></value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_vector_sink_f</key>
<param><key>id</key><value>qtgui_vector_sink_f_0</value></param>
<param><key>name</key><value>"Power Spectrum"</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>vlen</key><value>fftlen</value></param>
<param><key>x_axis_label</key><value>"Freq (MHz)"</value></param>
<param><key>x_start</key><value>freq_M - (samp_M/2)</value></param>
<param><key>x_step</key><value>float(samp_M)/fftlen</value></param>
<param><key>x_units</key><value>"(MHz)"</value></param>
<param><key>y_axis_label</key><value>"Power (dBFS)"</value></param>
<param><key>y_units</key><value>"dBFS"</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0</value></param>
<param><key>comment</key><value>to 500kS/s</value></param>
<param><key>decim</key><value>int(samp_M *2 * 5)</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>interp</key><value>1 * 5</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_1</value></param>
<param><key>decim</key><value>125</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>interp</key><value>24</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>sigt</value></param>
<param><key>comment</key><value>periodogram (dB scale)</value></param>
<param><key>stream_id</key><value>signal_tuned</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0</value></param>
<param><key>comment</key><value>periodogram (dB scale)</value></param>
<param><key>stream_id</key><value>psd_dB</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_0</value></param>
<param><key>comment</key><value>periodogram (linear)</value></param>
<param><key>stream_id</key><value>psd_linear</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_1</value></param>
<param><key>comment</key><value>Incoming I-Q signal</value></param>
<param><key>stream_id</key><value>sig_in</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0</value></param>
<param><key>stream_id</key><value>psd_dB</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_1</value></param>
<param><key>stream_id</key><value>sig_in</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_1_0</value></param>
<param><key>stream_id</key><value>psd_linear</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_1_1</value></param>
<param><key>stream_id</key><value>psd_linear</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_1_2</value></param>
<param><key>stream_id</key><value>sig_in</value></param>
</block>
<connection><source_block_id>analog_nbfm_rx_0</source_block_id><sink_block_id>audio_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_nbfm_rx_0</source_block_id><sink_block_id>blocks_wavfile_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_pwr_squelch_xx_0</source_block_id><sink_block_id>analog_wfm_rcv_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_pwr_squelch_xx_0_0</source_block_id><sink_block_id>analog_nbfm_rx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>analog_wfm_rcv_0</source_block_id><sink_block_id>rational_resampler_xxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blah</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blah_0</source_block_id><sink_block_id>low_pass_filter_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_argmax_xx_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_argmax_xx_0</source_block_id><sink_block_id>amax_probe</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_squared_0</source_block_id><sink_block_id>virtual_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_0</source_block_id><sink_block_id>blocks_nlog10_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_moving_average_xx_0</source_block_id><sink_block_id>blocks_argmax_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>blocks_complex_to_mag_squared_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1</source_block_id><sink_block_id>blocks_moving_average_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>sigt</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_nlog10_ff_0</source_block_id><sink_block_id>virtual_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0</source_block_id><sink_block_id>fft_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>epy_block_0</source_block_id><sink_block_id>qtgui_vector_sink_f_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>fft_vxx_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>analog_pwr_squelch_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0_0</source_block_id><sink_block_id>analog_pwr_squelch_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>virtual_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>low_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_1</source_block_id><sink_block_id>audio_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_1</source_block_id><sink_block_id>blocks_wavfile_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0</source_block_id><sink_block_id>qtgui_vector_sink_f_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_1</source_block_id><sink_block_id>blocks_stream_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_1_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_1_1</source_block_id><sink_block_id>blocks_keep_one_in_n_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_1_2</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
