<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>run_options</key><value>run</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>bps</value></param>
<param><key>value</key><value>16</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>44100</value></param>
</block>
<block>
<key>blocks_wavfile_sink</key>
<param><key>id</key><value>blocks_wavfile_sink_0</value></param>
<param><key>bits_per_sample</key><value>bps</value></param>
<param><key>file</key><value>/home/piloteer/바탕화면/test.wav</value></param>
<param><key>nchan</key><value>2</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>blocks_wavfile_source</key>
<param><key>id</key><value>blocks_wavfile_source_0</value></param>
<param><key>file</key><value>/home/piloteer/바탕화면/1.wav</value></param>
<param><key>nchan</key><value>2</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>epy_block_0</value></param>
<param><key>_source_code</key><value>#!/usr/bin/env python

import numpy
import Queue
from gnuradio import gr

class zero_removal(gr.basic_block):

	#constructor
	def __init__(self, zeros_cnt = 5, threshold_amplitude = 0):
		gr.basic_block.__init__(self,
			name="Zero Remover",
			in_sig=[(numpy.float32),(numpy.float32)],
			out_sig=[(numpy.float32),(numpy.float32)])
			
		self.zeros_cnt = zeros_cnt
		self.threshold_amplitude = threshold_amplitude
		self.zeros_so_far = 0
		

	#The main worker
	def general_work(self, input_items, output_items):

		
		in0 = input_items[0]
		in1 = input_items[1]
		out0 = output_items[0]
		out1 = output_items[1]
		
		#length of data to process
		proc_len = min(len(output_items[0]), len(output_items[1]), len(out0), len(out1))
		
		#skip if the data is too short
		if(proc_len &lt;= 0):
			return 0
						
		#do!
		store_cnt = 0
		for i in range (0, proc_len):
			if abs(in0[i]) &lt;= self.threshold_amplitude and abs(in1[i]) &lt;= self.threshold_amplitude:
				self.zeros_so_far += 1
			else:
				self.zeros_so_far = 0
				
			if self.zeros_so_far &lt; self.zeros_cnt:
				out0[store_cnt] = in0[i]
				out1[store_cnt] = in1[i]
				store_cnt += 1
				
		#consume
		self.consume_each(proc_len)
		return store_cnt
</value></param>
<param><key>threshold_amplitude</key><value>0.001</value></param>
<param><key>zeros_cnt</key><value>5</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<connection><source_block_id>blocks_wavfile_source_0</source_block_id><sink_block_id>epy_block_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_wavfile_source_0</source_block_id><sink_block_id>epy_block_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>epy_block_0</source_block_id><sink_block_id>blocks_wavfile_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>epy_block_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>epy_block_0</source_block_id><sink_block_id>blocks_wavfile_sink_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>epy_block_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
</flow_graph>
